# IAR project bldc.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\cmsis; ..\..\stm32\inc; ..\..\motor\inc; ..\..\shell\inc; ..\..\board\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: bldc.srec
  ILINK.IlinkOutputFile: bldc.out
  ILINK.IlinkIcfFile: ..\stm32f103rb.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..; ..\stm32\inc; ..\pmsm\inc
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: stm32f103rb.icf
  group (top)
    ../../: config.h debug.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group board/inc
    ../../board/inc/: adc.h board.h board_debug.h console.h led.h pwm.h time.h vsm.h
  group board/src
    ../../board/src/: adc.c board.c board_debug.c console.c led.c pwm.c time.c vsm.c
  group cmsis
    ../../cmsis/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group ewarm
    ../: read.c startup_stm32f10x_md.s write.c
  group motor/inc
    ../../motor/inc/: math.h motor.h motor_debug.h normalize.h pid.h smo.h vector.h
  group motor/src
    ../../motor/src/: math.c motor.c motor_debug.c pid.c smo.c vector.c
  group shell/inc
    ../../shell/inc/: cmd.h shell.h
  group shell/src
    ../../shell/src/: cmd.c cmd_debug.c cmd_motor.c shell.c
  group stm32/inc
    ../../stm32/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group stm32/src
    ../../stm32/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
